# Repository HiImYann/MacropadPrototype01

## KiCad design KiCad Project/Tutorial.kicad_pcb

Parts:
C1, C2: 22pF; C_0805_2012Metric
C3, C4, C5, C6: 0.1uF; C_0805_2012Metric
C7: 4.7uF; C_0805_2012Metric
C8: 1uF; C_0805_2012Metric
D1, D2, D3, D4, D5: D; D_SOD-123
F1: 500mA
J1: USB_mini_micro_B; USB_miniB_hirose_5S8
K1, K2, K3, K4: KEYSW; Mx_Alps_100
K5: KEYSW; Mx_Alps_200
R1, R2: 10k; R_0805_2012Metric
R3, R4: 22; R_0805_2012Metric
SW1: SW_PUSH; SKQG-1155865
U1: ATMEGA32U4; TQFP-44_10x10mm_P0.8mm
Y2: 16Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.5 (GND), J1.6 (SHIELD), R2.1, SW1.1, U1.5 (UGnd), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), Y2.2, Y2.4
unnamed: C1.1, U1.17 (XTAL2), Y2.3
unnamed: C2.1, U1.16 (XTAL1), Y2.1
unnamed: C8.1, U1.6 (UCap)
unnamed: D1.2, K1.2
unnamed: D2.2, K2.2
unnamed: D3.2, K3.2
unnamed: D4.2, K4.2
unnamed: D5.2, K5.2
unnamed: F1.1, U1.2 (UVcc)
unnamed: J1.2 (D-), R3.2
unnamed: J1.3 (D+), R4.2
unnamed: R1.1, SW1.2, U1.13 (~RESET)
unnamed: R2.2, U1.33 (~HWB/PE2)
unnamed: R3.1, U1.3 (D-)
unnamed: R4.1, U1.4 (D+)
VCC: C3.1, C4.1, C5.1, C6.1, C7.1, F1.2, J1.1 (VUSB), R1.2, U1.7 (VBus), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
col0: K1.1, K3.1, U1.41 (PF0)
col1: K2.1, K4.1, K5.1, U1.39 (PF4)
row0: D1.1, D2.1, U1.38 (PF5)
row1: D3.1, D4.1, U1.37 (PF6)
row2: D5.1, U1.40 (PF1)

Board: 2 copper layers, 49.7 x 82.4 mm, 27 parts (22 on the bottom side), 22 nets.

File BOM + Centroid/BOM.xlsx:

Comment | Designator | Footprint | LCSC
22pF | C1,C2 | Capacitor_SMD:C_0805_2012Metric
0.1uF | C3,C4,C5,C6 | Capacitor_SMD:C_0805_2012Metric
4.7uF | C7 | Capacitor_SMD:C_0805_2012Metric
1uF | C8 | Capacitor_SMD:C_0805_2012Metric
D | D1,D2,D3,D4,D5 | Diode_SMD:D_SOD-123
500mA | F1 | Fuse:Fuse_1206_3216Metric
USB_mini_micro_B | J1 | random-keyboard-parts:Molex-0548190589
KEYSW | K1,K2,K3,K4 | keebs:Mx_Alps_100
KEYSW | K5 | keebs:Mx_Alps_200
10k | R1,R2 | Resistor_SMD:R_0805_2012Metric
22 | R3,R4 | Resistor_SMD:R_0805_2012Metric
SW_PUSH | SW1 | random-keyboard-parts:SKQG-1155865
ATMEGA32U4 | U1 | Package_QFP:TQFP-44_10x10mm_P0.8mm
16Mhz | Y2 | Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm

## Commit log

2020-06-16 Added all the files
2020-06-16 Added fuse
